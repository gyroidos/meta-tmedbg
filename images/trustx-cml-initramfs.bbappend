PACKAGE_INSTALL += " \
	gdb \
	valgrind \
	bridge-utils \
	iproute2 \
	usbutils \
	bash \
	bash-completion \
	perl-module-file-basename \
	perl-module-file-glob \
	tcpdump \
"
