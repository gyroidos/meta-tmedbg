FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " file://rpc.cfg file://mdev.cfg"
